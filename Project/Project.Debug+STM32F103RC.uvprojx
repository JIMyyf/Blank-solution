# Keil uVision project Project.Debug+STM32F103RC.uvprojx, settings and files
target Debug+STM32F103RC (6210000::V6.21::.\ARMCLANG6.21.1)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality -Wno-license-management
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: RTE/Device/STM32F103RC/ac6_linker_script.sct.src
  link misc: --entry=Reset_Handler --info summarysizes --summary_stderr --diag_suppress=L6314W
  group Source Files
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
